# Keil uVision project microrealms.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32L031K6Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: microrealms
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: stm32l031lib.c main.c realm.c music.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
